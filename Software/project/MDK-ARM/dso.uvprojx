# Keil uVision project dso.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dso +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ..\..\drivers\inc;..\..\config;..\..\app\inc;..\..\debug;..\..\bsp\Core\Inc;..\..\bsp\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\bsp\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\bsp\Drivers\CMSIS\DSP\Include;..\..\dsp;..\..\wdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f407xx.s
  group bsp
    ../../bsp/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
    ../../bsp/Core/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group app
    ../../app/src/: main.c WinMain.c protocol.c
    ../../config/: app_cfg.c
  group drivers
    ../../drivers/src/: bsp_adc.c bsp_uart.c bsp_dac.c bsp_led.c
  group debug
    ../../debug/: debug.c
  group dsp_lib
    ../../dsp/: arm_cortexM4lf_math.lib bsp_dsp_fft.c cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
  group wdg
    ../../wdg/: iwdg.c
software components: CMSIS:CORE 5.4.0
